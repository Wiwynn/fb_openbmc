IMAGE_INSTALL:append = " yaap"
