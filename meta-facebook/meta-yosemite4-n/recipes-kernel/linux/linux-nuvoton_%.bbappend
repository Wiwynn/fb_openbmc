FILESEXTRAPATHS:prepend := "${THISDIR}/linux-nuvoton:"
SRC_URI += "file://yosemite4.cfg"
