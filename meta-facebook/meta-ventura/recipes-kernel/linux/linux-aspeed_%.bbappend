FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed:"

SRC_URI += " \
    file://0001-meta-facebook-ventura-Add-Linux-device-tree-related.patch \
"
