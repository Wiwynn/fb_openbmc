RDEPENDS:${PN}-ptest:remove = "\
    perl-module-b \
    perl-module-base \
    perl-module-cwd \
    perl-module-digest \
    perl-module-digest-md5 \
    perl-module-digest-sha \
    perl-module-file-basename \
    perl-module-file-spec \
    perl-module-file-temp \
    perl-module-i18n-langinfo \
    perl-module-io-socket \
    perl-module-ipc-open2 \
    perl-module-list-util \
    perl-module-memoize \
    perl-module-storable \
    perl-module-time-hires \
"
