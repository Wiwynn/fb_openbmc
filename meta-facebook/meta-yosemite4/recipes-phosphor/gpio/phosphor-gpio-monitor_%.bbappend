FILESEXTRAPATHS:prepend := "${THISDIR}/phosphor-gpio-monitor:"

SRC_URI += "file://configure-nic-mctp-endpoint"


