FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://0001-configuration-add-yosemite4-config-for-Nuvoton-BMC.patch \
"
