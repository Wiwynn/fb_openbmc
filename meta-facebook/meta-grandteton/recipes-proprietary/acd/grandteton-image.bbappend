# Copyright (c) Meta Platforms, Inc. and affiliates. (http://www.meta.com)

# Include modules in rootfs
IMAGE_INSTALL:append:grandteton = " \
  acd \
  "
