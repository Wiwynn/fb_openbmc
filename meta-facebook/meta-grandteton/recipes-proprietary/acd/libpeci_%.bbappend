# Copyright 2022-present Facebook. All Rights Reserved.
EAGLESTREAM_CRASHDUMP = "True"
