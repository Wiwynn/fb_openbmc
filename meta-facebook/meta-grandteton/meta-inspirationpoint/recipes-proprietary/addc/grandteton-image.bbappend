IMAGE_INSTALL:append = " addc"
