LINUX_VERSION_EXTENSION = "-wedge100"

COMPATIBLE_MACHINE = "wedge100"

KERNEL_CONFIG_COMMAND = "oe_runmake wedge100_defconfig && oe_runmake oldconfig"
