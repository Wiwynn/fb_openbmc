# Copyright 2018-present Facebook. All Rights Reserved.

# Include modules in rootfs
IMAGE_INSTALL += " \
  acd-analyzer \
  "
