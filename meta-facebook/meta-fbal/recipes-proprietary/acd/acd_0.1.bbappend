# Copyright 2017-present Facebook. All Rights Reserved.

FILESEXTRAPATHS:append := "${THISDIR}/files:"
LOCAL_URI += "file://PlatInfo.cpp "
