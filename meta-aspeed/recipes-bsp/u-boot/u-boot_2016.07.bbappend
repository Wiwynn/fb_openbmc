# Disable the OSS mtd patrs patch
patch_mtdparts_for_oss () {
    bbdebug 1 "Bypass the oss mtdparts patch"
}
