require u-boot-aspeed.inc
require u-boot-tools.inc

PV = "v2019.04"
SRC_URI = "file://u-boot-v2019.04"
